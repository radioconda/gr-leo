<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>leo_channel</value></param>
<param><key>author</key><value>Kostis Triantafyllakis (kostastriantaf@gmail.com)</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>LEO channel simulation</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pointing_error</value></param>
<param><key>value</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>80e3</value></param>
</block>
<block>
<key>variable_antenna</key>
<param><key>id</key><value>satellite_rx_antenna</value></param>
<param><key>aperture_efficiency</key><value>55</value></param>
<param><key>beamwidth</key><value>360</value></param>
<param><key>boom_length</key><value>2.35</value></param>
<param><key>circumference</key><value>1</value></param>
<param><key>diameter</key><value>5.4</value></param>
<param><key>frequency</key><value>435e6</value></param>
<param><key>gain</key><value>6</value></param>
<param><key>loop</key><value>0.5</value></param>
<param><key>pointing_error</key><value>pointing_error</value></param>
<param><key>polarization</key><value>3</value></param>
<param><key>rolloff_gain</key><value>0</value></param>
<param><key>turn_spacing</key><value>0.25</value></param>
<param><key>turns</key><value>10</value></param>
<param><key>type</key><value>1</value></param>
</block>
<block>
<key>variable_antenna</key>
<param><key>id</key><value>satellite_tx_antenna</value></param>
<param><key>aperture_efficiency</key><value>55</value></param>
<param><key>beamwidth</key><value>50</value></param>
<param><key>boom_length</key><value>2.35</value></param>
<param><key>circumference</key><value>1</value></param>
<param><key>diameter</key><value>5.4</value></param>
<param><key>frequency</key><value>435e6</value></param>
<param><key>gain</key><value>14</value></param>
<param><key>loop</key><value>0.5</value></param>
<param><key>pointing_error</key><value>pointing_error</value></param>
<param><key>polarization</key><value>3</value></param>
<param><key>rolloff_gain</key><value>0</value></param>
<param><key>turn_spacing</key><value>0.25</value></param>
<param><key>turns</key><value>10</value></param>
<param><key>type</key><value>5</value></param>
</block>
<block>
<key>variable_antenna</key>
<param><key>id</key><value>tracker_rx_antenna</value></param>
<param><key>aperture_efficiency</key><value>55</value></param>
<param><key>beamwidth</key><value>360</value></param>
<param><key>boom_length</key><value>2.35</value></param>
<param><key>circumference</key><value>1</value></param>
<param><key>diameter</key><value>5.4</value></param>
<param><key>frequency</key><value>435e6</value></param>
<param><key>gain</key><value>6</value></param>
<param><key>loop</key><value>0.5</value></param>
<param><key>pointing_error</key><value>pointing_error</value></param>
<param><key>polarization</key><value>3</value></param>
<param><key>rolloff_gain</key><value>0</value></param>
<param><key>turn_spacing</key><value>0.25</value></param>
<param><key>turns</key><value>10</value></param>
<param><key>type</key><value>1</value></param>
</block>
<block>
<key>variable_antenna</key>
<param><key>id</key><value>tracker_tx_antenna</value></param>
<param><key>aperture_efficiency</key><value>55</value></param>
<param><key>beamwidth</key><value>50</value></param>
<param><key>boom_length</key><value>2.35</value></param>
<param><key>circumference</key><value>1</value></param>
<param><key>diameter</key><value>5.4</value></param>
<param><key>frequency</key><value>145.8e6</value></param>
<param><key>gain</key><value>14</value></param>
<param><key>loop</key><value>0.5</value></param>
<param><key>pointing_error</key><value>pointing_error</value></param>
<param><key>polarization</key><value>0</value></param>
<param><key>rolloff_gain</key><value>0</value></param>
<param><key>turn_spacing</key><value>0.25</value></param>
<param><key>turns</key><value>10</value></param>
<param><key>type</key><value>5</value></param>
</block>
<block>
<key>variable_leo_model_def</key>
<param><key>id</key><value>variable_leo_model_def_0</value></param>
<param><key>pointing_attenuation_enum</key><value>0</value></param>
<param><key>atmo_gases_attenuation</key><value>1</value></param>
<param><key>doppler_shift_enum</key><value>7</value></param>
<param><key>fspl_attenuation_enum</key><value>5</value></param>
<param><key>value</key><value>'fine'</value></param>
<param><key>enable_link_margin</key><value>True</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>precipitation_attenuation</key><value>3</value></param>
<param><key>rainfall_rate</key><value>90</value></param>
<param><key>surface_watervap_density</key><value>7.5</value></param>
<param><key>temperature</key><value>20</value></param>
<param><key>tracker</key><value>variable_tracker_0</value></param>
</block>
<block>
<key>variable_satellite</key>
<param><key>id</key><value>variable_satellite_0</value></param>
<param><key>rx_antenna</key><value>satellite_rx_antenna</value></param>
<param><key>tx_antenna</key><value>satellite_tx_antenna</value></param>
<param><key>comm_freq_rx</key><value>435e6</value></param>
<param><key>comm_freq_tx</key><value>435e6</value></param>
<param><key>value</key><value>'ok'</value></param>
<param><key>tle_1</key><value>1 84001U          20001.00000000  .00000000  00000-0  50000-4 0    08</value></param>
<param><key>tle_2</key><value>2 84001  97.0000 156.0000 0001497   0.0000 124.0000 15.90816786    02</value></param>
<param><key>tle_title</key><value>QUBIK</value></param>
<param><key>tx_power_dbm</key><value>27</value></param>
</block>
<block>
<key>variable_tracker</key>
<param><key>id</key><value>variable_tracker_0</value></param>
<param><key>gs_alt</key><value>1</value></param>
<param><key>rx_antenna</key><value>tracker_rx_antenna</value></param>
<param><key>tx_antenna</key><value>tracker_tx_antenna</value></param>
<param><key>comm_freq_rx</key><value>435e6</value></param>
<param><key>comm_freq_tx</key><value>435E6</value></param>
<param><key>value</key><value>'fine'</value></param>
<param><key>gs_lat</key><value>37.158136</value></param>
<param><key>gs_lon</key><value>22.893258</value></param>
<param><key>obs_end</key><value>2020-01-06T01:59:13.0000000Z</value></param>
<param><key>obs_start</key><value>2020-01-06T01:50:41.0000000Z</value></param>
<param><key>satellite_info</key><value>variable_satellite_0</value></param>
<param><key>tx_power_dbm</key><value>37</value></param>
<param><key>time_resolution_us</key><value>1000000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>1380.384265</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1000.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>leo_channel_model</key>
<param><key>id</key><value>leo_channel_model_0</value></param>
<param><key>model</key><value>variable_leo_model_def_0</value></param>
<param><key>value</key><value>'fine'</value></param>
<param><key>imp</key><value>1</value></param>
<param><key>noise_type</key><value>1</value></param>
<param><key>snr</key><value>-100</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>satnogs_multi_format_msg_sink</key>
<param><key>id</key><value>satnogs_multi_format_msg_sink_0</value></param>
<param><key>filename</key><value>/home/ctriant/qubik_link_margin_27dbm_helix.csv</value></param>
<param><key>outstream</key><value>False</value></param>
<param><key>timestamp</key><value>False</value></param>
<param><key>format</key><value>0</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>leo_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>leo_channel_model_0</source_block_id><sink_block_id>satnogs_multi_format_msg_sink_0</sink_block_id><source_key>csv</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>leo_channel_model_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>leo_channel_model_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>leo_channel_model_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
