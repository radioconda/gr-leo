<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>leo_channel</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>320e3</value></param>
</block>
<block>
<key>variable_satellite</key>
<param><key>id</key><value>variable_satellite_0</value></param>
<param><key>freq_downlink</key><value>500e6</value></param>
<param><key>value</key><value>'ok'</value></param>
<param><key>name</key><value></value></param>
<param><key>tle_1</key><value>1 25544U 98067A   18268.52547184  .00016717  00000-0  10270-3 0  9019</value></param>
<param><key>tle_2</key><value>2 25544  51.6373 238.6885 0003885 206.9748 153.1203 15.53729445 14114</value></param>
<param><key>tle_title</key><value>ISS</value></param>
<param><key>freq_uplink</key><value>340e6</value></param>
</block>
<block>
<key>variable_test_model_def</key>
<param><key>id</key><value>variable_test_model_def_0</value></param>
<param><key>value</key><value>'fine'</value></param>
<param><key>tracker</key><value>variable_tracker_0</value></param>
</block>
<block>
<key>variable_tracker</key>
<param><key>id</key><value>variable_tracker_0</value></param>
<param><key>gs_alt</key><value>39</value></param>
<param><key>value</key><value>'fine'</value></param>
<param><key>gs_lat</key><value>35.3333</value></param>
<param><key>gs_lon</key><value>25.1833</value></param>
<param><key>name</key><value></value></param>
<param><key>obs_end</key><value>2018-09-25T15:58:35.0000000Z</value></param>
<param><key>obs_start</key><value>2018-09-25T15:48:25.0000000Z</value></param>
<param><key>satellite_info</key><value>variable_satellite_0</value></param>
<param><key>time_resolution_us</key><value>1e6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>leo_channel_model</key>
<param><key>id</key><value>leo_channel_model_0</value></param>
<param><key>model</key><value>variable_test_model_def_0</value></param>
<param><key>value</key><value>'fine'</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>leo_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>leo_channel_model_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
